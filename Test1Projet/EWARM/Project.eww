<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Projet5ASimulationResauxDeNeurones.ewp</path>
  </project>
  <batchBuild />
</workspace>
